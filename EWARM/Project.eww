<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Core_OS_For_Smart_Watch.ewp</path>
  </project>
  <batchBuild />
</workspace>
